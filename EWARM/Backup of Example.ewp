# IAR project Backup of Example.ewp, settings and files
configuration Example (ARM, debug)
  General.OGChipSelectEditMenu: FM33LR02X FMSH FM33LR02X
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 29
  General.FPU2: 0
  ICCARM.CCDefines: FM33LR0XX; USE_FULL_ASSERT
  ICCARM.CCIncludePath2: ../Drivers/CMSIS/Inculde; ../Drivers/CMSIS/Device/FM/FM33xx/Include; ../Inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Example.hex
  ILINK.IlinkOutputFile: Example.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ../Drivers/CMSIS/Device/FM/FM33xx/Source/Templates/iar/: startup_fm33fh0xx.s
  group Application/Device
    ../Device/: Intrrupt.c
  group Application/User
    ../Src/: main.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/FM/FM33xx/Source/: system_fm33lr0xx.c
