# IAR project Example.ewp, settings and files
configuration Example (ARM, debug)
  General.OGChipSelectEditMenu: FM33LR02x FMSH FM33LR02x
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 29
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\Drivers\CMSIS\Device\FM\FM33xx\Include; ..\Inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Example.hex
  ILINK.IlinkOutputFile: Example.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/Device
    ../Device/: Intrrupt.c
  group Application/EWARM
    ../Drivers/CMSIS/Device/FM/FM33xx/Source/Templates/iar/: startup_fm33fh0xx.s
  group Application/User
    ../Src/: main.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/FM/FM33xx/Source/: system_fm33lr0xx.c
